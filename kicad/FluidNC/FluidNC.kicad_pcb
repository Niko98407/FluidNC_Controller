# Repository Niko98407/FluidNC_Controller

## KiCad design kicad/FluidNC/FluidNC.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C11, C12, C39: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C40, C41: 10u; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C9, C10: 220u; CP_Elec_10x7.9
D1: BAT60A; D_SOD-323_HandSoldering
D2, D3: bl; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: SS34; D_SMA
D6, D7: gn; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: 5A; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
J1: USB_C_Receptacle_USB2.0; USB_C
J31: Conn_01x02_Socket; WAGO_250-202_1x02_P3.50mm
L1: 33u; L_6.3x6.3_H3
Q1, Q2: BC847; SOT-23
R1, R2: 5k1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_RESET; SW_SPST_B3U-1000P
SW2: SW_BOOT; SW_SPST_B3U-1000P
U1: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U2: ESP32-WROOM-32
U8: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U9: LM2596S-5; TO-263-5_TabPin3

Connections:
+3.3V: C1.1, C6.1, C7.1, C39.1, C40.1, C41.1, D2.2 (A), D3.2 (A), R9.1, R10.1, R23.1, U1.4 (V3), U1.16 (VCC), U2.2 (VDD), U8.2 (VO); also elsewhere on the board
+5V: C5.1, C8.1, D1.1 (K), U8.3 (VI); also elsewhere on the board
+5VP: C10.1, C12.1, L1.2, R22.1, U9.4 (FB); also elsewhere on the board
+24V: C9.1, C11.1, F1.2, U9.1 (VIN); also elsewhere on the board
D+: J1.A6 (D+), J1.B6 (D+), U1.5 (UD+)
D-: J1.A7 (D-), J1.B7 (D-), U1.6 (UD-)
ESP_EN: C2.2, C4.1, Q1.3 (C), R9.2, SW1.2, U2.3 (EN)
ESP_IO0: C3.2, Q2.3 (C), R10.2, SW2.2, U2.25 (IO0)
ESP_RX: R3.2, U2.34 (RXD0/IO3)
ESP_TX: R4.2, U2.35 (TXD0/IO1)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C39.2, C40.2, C41.2, D7.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.2, SW1.1, SW2.1, U1.1 (GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND), U8.1 (GND); also elsewhere on the board
GND1: C9.2, C10.2, C11.2, C12.2, D5.2 (A), D6.1 (K), J31.2, U9.3 (GND), U9.5 (~ON/OFF); also elsewhere on the board
IO2_DONOTUSE: U2.24 (IO2)
IO4_MACRO1: U2.26 (IO4); also elsewhere on the board
IO5_SPI_CS: U2.29 (IO5); also elsewhere on the board
IO12_DONOTUSE: U2.14 (IO12)
IO13_PAUSE: U2.16 (IO13); also elsewhere on the board
IO14_RESUME: U2.13 (IO14); also elsewhere on the board
IO15_DONOTUSE: U2.23 (IO15)
IO16_I2SO_BCK: U2.27 (IO16); also elsewhere on the board
IO17_I2SO_WS: U2.28 (IO17); also elsewhere on the board
IO18_SPI_SCK: U2.30 (IO18); also elsewhere on the board
IO19_SPI_MISO: U2.31 (IO19); also elsewhere on the board
IO21_I2SO_DATA: U2.33 (IO21); also elsewhere on the board
IO22_HOME4: U2.36 (IO22); also elsewhere on the board
IO23_SPI_MOSI: U2.37 (IO23); also elsewhere on the board
IO25_HOME6: U2.10 (IO25); also elsewhere on the board
IO26_MACRO2: U2.11 (IO26); also elsewhere on the board
IO27_MACRO3: U2.12 (IO27); also elsewhere on the board
IO32_PWM1: U2.8 (IO32); also elsewhere on the board
IO33_PWM2: U2.9 (IO33); also elsewhere on the board
IO34_HOME2: U2.6 (IO34); also elsewhere on the board
IO35_HOME3: U2.7 (IO35); also elsewhere on the board
IO36_HOME1: U2.4 (SENSOR_VP); also elsewhere on the board
IO39_HOME5: U2.5 (SENSOR_VN); also elsewhere on the board
unnamed: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D2.1 (K), R5.2
unnamed: D3.1 (K), R6.2
unnamed: D5.1 (K), L1.1, U9.2 (OUT)
unnamed: D6.2 (A), R22.2
unnamed: D7.2 (A), R23.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: F1.1, J31.1
unnamed: Q1.1 (B), R7.2
unnamed: Q2.1 (B), R8.2
RX: R4.1, R6.1, U1.3 (RXD)
TX: R3.1, R5.1, U1.2 (TXD)
~DTR: Q2.2 (E), R7.1, U1.13 (~DTR)
~RTS: Q1.2 (E), R8.1, U1.14 (~RTS)

Parts:
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C72: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C38, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D4, D8, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: rt; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J2, J3, J28, J29, J30, J32: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
J17, J20: Conn_01x04_Socket; WAGO_250-204_1x04_P3.50mm
J18, J19: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J21, J22, J23, J24, J25, J26: Conn_01x08_Socket; WAGO_250-208_1x08_P3.50mm
J27: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R11, R13, R14, R16, R17, R18, R19, R70, R71, R75, R79, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R20: 20k; Potentiometer_Piher_PT-6-V_Vertical
R15, R21: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R96, R97: 5k1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3, U4, U5, U6: 74HCT595; SOIC-16
U7, U26: ISO1H811G; PG-DSO-36
U10, U11: ADuM120N; SOIC-8_3.9x4.9mm_P1.27mm
U12: LM358; SO-8_3.9x4.9mm_P1.27mm

Connections:
0-10V_1: J17.3, R12.1, U12.1
0-10V_2: J20.3, R20.1, U12.7
+3.3V: C13.1, C14.1, U10.1 (VDD1), U11.1 (VDD1); also elsewhere on the board
+5V: C17.1, C18.1, C19.1, C20.1, C21.1, C72.1, D4.1 (K), D8.1 (K), J27.1, U3.10 (~SRCLR), U3.16 (VCC), U4.10 (~SRCLR), U4.16 (VCC), U5.10 (~SRCLR), U5.16 (VCC), U6.10 (~SRCLR), U6.16 (VCC), U7.2 (VCC), U7.3 (~DIS), U26.2 (VCC), U26.3 (~DIS); also elsewhere on the board
+5VP: C15.1, C16.1, J18.3, J19.3, J22.1, J22.2, J22.3, J22.4, J22.5, J22.6, J22.7, J22.8, U10.8 (VDD2), U11.8 (VDD2); also elsewhere on the board
+24V: C22.1, J18.1, J19.1, J24.1, J24.2, J24.3, J24.4, J24.5, J24.6, J24.7, J24.8, U7.0 (Vbb), U12.8 (V+), U26.0 (Vbb); also elsewhere on the board
EN_STEPPER: U11.7 (VOA); also elsewhere on the board
GND: C13.2, C14.2, C17.2, C18.2, C19.2, C20.2, C21.2, C72.2, D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), J2.1, J3.1, J27.6, J28.1, U3.8 (GND), U3.13 (~OE), U4.8 (GND), U4.13 (~OE), U5.8 (GND), U5.13 (~OE), U6.8 (GND), U6.13 (~OE), U7.4 (~CS), U7.5 (~WR), U7.15 (GNDCC), U10.4 (GND1), U11.4 (GND1), U26.4 (~CS), U26.5 (~WR), U26.15 (GNDCC); also elsewhere on the board
GND1: C15.2, C16.2, C22.2, C23.2, C24.2, C31.2, C38.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, D27.1 (K), D28.1 (K), J17.4, J20.4, J23.1, J23.2, J23.3, J23.4, J23.5, J23.6, J23.7, J23.8, J26.1, J26.2, J26.3, J26.4, J26.5, J26.6, J26.7, J26.8, J29.1, J30.1, J32.1, R14.2, R16.2, R17.2, R19.2, R71.2, R75.2, R79.2, R83.2, R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.2, R91.2, R92.2, R93.2, R94.2, R95.2, U7.19 (GNDbb), U10.5 (GND2), U11.5 (GND2), U12.4 (V-), U26.19 (GNDbb); also elsewhere on the board
I2SO0_DIR6: R109.1, U3.15 (QA); also elsewhere on the board
I2SO1_STEP6: R110.1, U3.1 (QB); also elsewhere on the board
I2SO2_DIR5: R111.1, U3.2 (QC); also elsewhere on the board
I2SO3_STEP5: R112.1, U3.3 (QD); also elsewhere on the board
I2SO4_DIR4: R113.1, U3.4 (QE); also elsewhere on the board
I2SO5_STEP4: R114.1, U3.5 (QF); also elsewhere on the board
I2SO6_DIR3: R115.1, U3.6 (QG); also elsewhere on the board
I2SO7_STEP3: R116.1, U3.7 (QH); also elsewhere on the board
I2SO8_DIR2: R117.1, U4.15 (QA); also elsewhere on the board
I2SO9_STEP2: R118.1, U4.1 (QB); also elsewhere on the board
I2SO10_DIR1: R119.1, U4.2 (QC); also elsewhere on the board
I2SO11_STEP1: R120.1, U4.3 (QD); also elsewhere on the board
I2SO12_OUT_MIST: U4.4 (QE), U7.6 (D0)
I2SO13_OUT_FLOOD: U4.5 (QF), U7.7 (D1)
I2SO14_EN_STEPPER: R121.1, U4.6 (QG), U11.2 (VIA)
I2SO15_USEROUT0: U4.7 (QH), U7.8 (D2)
I2SO16_USEROUT1: U5.15 (QA), U7.9 (D3)
I2SO17_USEROUT2: U5.1 (QB), U7.10 (D4)
I2SO18_USEROUT3: U5.2 (QC), U7.11 (D5)
I2SO19_USEROUT4: U5.3 (QD), U7.12 (D6)
I2SO20_USEROUT5: U5.4 (QE), U7.13 (D7)
I2SO21_USEROUT6: U5.5 (QF), U26.6 (D0)
I2SO22_USEROUT7: U5.6 (QG), U26.7 (D1)
I2SO23_USEROUT8: U5.7 (QH), U26.8 (D2)
I2SO24_USEROUT9: U6.15 (QA), U26.9 (D3)
I2SO25_USEROUT10: U6.1 (QB), U26.10 (D4)
I2SO26_USEROUT11: U6.2 (QC), U26.11 (D5)
I2SO27_USEROUT12: U6.3 (QD), U26.12 (D6)
I2SO28_USEROUT13: U6.4 (QE), U26.13 (D7)
I2SO29_USEROUT14: U6.5 (QF)
I2SO30_USEROUT15: U6.6 (QG)
I2SO31_USEROUT16: U6.7 (QH)
IO5_SPI_CS: J27.2; also elsewhere on the board
IO16_I2SO_BCK: U3.11 (SRCLK), U4.11 (SRCLK), U5.11 (SRCLK), U6.11 (SRCLK); also elsewhere on the board
IO17_I2SO_WS: U3.12 (RCLK), U4.12 (RCLK), U5.12 (RCLK), U6.12 (RCLK); also elsewhere on the board
IO18_SPI_SCK: J27.3; also elsewhere on the board
IO19_SPI_MISO: J27.4; also elsewhere on the board
IO21_I2SO_DATA: U3.14 (SER); also elsewhere on the board
IO23_SPI_MOSI: J27.5; also elsewhere on the board
IO32_PWM1: U10.2 (VIA); also elsewhere on the board
IO33_PWM2: U10.3 (VIB); also elsewhere on the board
unnamed: D4.2 (A), R11.1
unnamed: D8.2 (A), R70.1
unnamed: C31.1, D11.2 (A), J21.8, U7.35 (OUT0), U7.36 (OUT0)
unnamed: D11.1 (K), R71.1
unnamed: C38.1, D12.2 (A), J21.7, U7.33 (OUT1), U7.34 (OUT1)
unnamed: D12.1 (K), R75.1
unnamed: C73.1, D13.2 (A), J21.6, U7.31 (OUT2), U7.32 (OUT2)
unnamed: D13.1 (K), R79.1
unnamed: C74.1, D14.2 (A), J21.5, U7.29 (OUT3), U7.30 (OUT3)
unnamed: D14.1 (K), R83.1
unnamed: C75.1, D15.2 (A), J21.4, U7.27 (OUT4), U7.28 (OUT4)
unnamed: D15.1 (K), R84.1
unnamed: C76.1, D16.2 (A), J21.3, U7.25 (OUT5), U7.26 (OUT5)
unnamed: D16.1 (K), R85.1
unnamed: C77.1, D17.2 (A), J21.2, U7.23 (OUT6), U7.24 (OUT6)
unnamed: D17.1 (K), R86.1
unnamed: C78.1, D18.2 (A), J21.1, U7.21 (OUT7), U7.22 (OUT7)
unnamed: D18.1 (K), R87.1
unnamed: C79.1, D19.2 (A), J25.8, U26.35 (OUT0), U26.36 (OUT0)
unnamed: D19.1 (K), R88.1
unnamed: C80.1, D20.2 (A), J25.7, U26.33 (OUT1), U26.34 (OUT1)
unnamed: D20.1 (K), R89.1
unnamed: C81.1, D21.2 (A), J25.6, U26.31 (OUT2), U26.32 (OUT2)
unnamed: D21.1 (K), R90.1
unnamed: C82.1, D22.2 (A), J25.5, U26.29 (OUT3), U26.30 (OUT3)
unnamed: D22.1 (K), R91.1
unnamed: C83.1, D23.2 (A), J25.4, U26.27 (OUT4), U26.28 (OUT4)
unnamed: D23.1 (K), R92.1
unnamed: C84.1, D24.2 (A), J25.3, U26.25 (OUT5), U26.26 (OUT5)
unnamed: D24.1 (K), R93.1
unnamed: C85.1, D25.2 (A), J25.2, U26.23 (OUT6), U26.24 (OUT6)
unnamed: D25.1 (K), R94.1
unnamed: C86.1, D26.2 (A), J25.1, U26.21 (OUT7), U26.22 (OUT7)
unnamed: D26.1 (K), R95.1
unnamed: D27.2 (A), R96.2
unnamed: D28.2 (A), R97.2
unnamed: D40.2 (A), R109.2
unnamed: D41.2 (A), R110.2
unnamed: D42.2 (A), R111.2
unnamed: D43.2 (A), R112.2
unnamed: D44.2 (A), R113.2
unnamed: D45.2 (A), R114.2
unnamed: D46.2 (A), R115.2
unnamed: D47.2 (A), R116.2
unnamed: D48.2 (A), R117.2
unnamed: D49.2 (A), R118.2
unnamed: D50.2 (A), R119.2
unnamed: D51.2 (A), R120.2
unnamed: D52.2 (A), R121.2
unnamed: J17.1, J18.2
unnamed: J19.2, J20.1
unnamed: R12.2, R15.2
unnamed: R20.2, R21.2
unnamed: U3.9 (QH'), U4.14 (SER)
unnamed: U4.9 (QH'), U5.14 (SER)
unnamed: U5.9 (QH'), U6.14 (SER)
unnamed: R11.2, U7.14 (~DIAG)
unnamed: C23.1, R13.2, U12.3 (+)
unnamed: R15.1, R16.1, U12.2 (-)
unnamed: C24.1, R18.2, U12.5 (+)
unnamed: R19.1, R21.1, U12.6 (-)
unnamed: R70.2, U26.14 (~DIAG)
PWM1: J17.2, R13.1, R14.1, R96.1, U10.7 (VOA)
PWM2: J20.2, R17.1, R18.1, R97.1, U10.6 (VOB)

Parts:
C48, C51, C53, C55, C60, C61, C62, C63, C68, C69, C70: 100p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C49, C50, C52, C54, C56, C57, C58, C59, C64, C65, C66: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C67, C71: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39: ye; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J10, J11, J12, J13, J14, J15: Conn_01x02_Socket; WAGO_250-202_1x02_P3.50mm
J16: Conn_01x12_Socket; WAGO_250-212_1x12_P3.50mm
R24: 5k6; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R31, R33, R36, R38, R41, R43, R52, R53, R54, R55, R60, R61, R62, R63, R72, R73, R74, R80, R81, R82: 1k5; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26, R32, R37, R42, R56, R57, R58, R59, R76, R77, R78, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27, R29, R34, R39, R44, R46, R48, R50, R64, R66, R68: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R30, R35, R40, R45, R47, R49, R51, R65, R67, R69: 2k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW9: Macro 1; SW_SPST_B3U-1000P
SW10: Macro 2; SW_SPST_B3U-1000P
SW11: Macro 3; SW_SPST_B3U-1000P
SW12: Resume; SW_SPST_B3U-1000P
SW13: Pause; SW_SPST_B3U-1000P
U21, U24, U25: LTV-847; DIP-16_W8.89mm_SMDSocket_LongPads
U22, U23: 74HC14; SO-14_3.9x8.65mm_P1.27mm

Connections:
+5V: C67.1, C71.1, R26.2, R32.2, R37.2, R42.2, R56.2, R57.2, R58.2, R59.2, R76.2, R77.2, R78.2, U22.14 (VCC), U23.14 (VCC); also elsewhere on the board
+24V: J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J16.4, J16.6, J16.8, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2; also elsewhere on the board
GND: C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, R28.1, R30.1, R35.1, R40.1, R45.1, R47.1, R49.1, R51.1, R65.1, R67.1, R69.1, U21.11, U21.13, U21.15, U22.7 (GND), U23.7 (GND), U23.13, U24.9, U24.11, U24.13, U24.15, U25.9, U25.11, U25.13, U25.15; also elsewhere on the board
GND1: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), J16.10, J16.11, J16.12, U21.2, U21.4, U21.6, U24.2, U24.4, U24.6, U24.8, U25.2, U25.4, U25.6, U25.8; also elsewhere on the board
HOME1: J10.1, R24.1, R98.1
HOME2: J11.1, R33.1, R99.1
HOME3: J12.1, R38.1, R100.1
HOME4: J13.1, R43.1, R101.1
HOME5: J14.1, R60.1, R102.1
HOME6: J15.1, R61.1, R103.1
IO4_MACRO1: R48.1, R49.2; also elsewhere on the board
IO13_PAUSE: R66.1, R67.2; also elsewhere on the board
IO14_RESUME: R68.1, R69.2; also elsewhere on the board
IO22_HOME4: R39.1, R40.2; also elsewhere on the board
IO25_HOME6: R46.1, R47.2; also elsewhere on the board
IO26_MACRO2: R50.1, R51.2; also elsewhere on the board
IO27_MACRO3: R64.1, R65.2; also elsewhere on the board
IO34_HOME2: R29.1, R30.2; also elsewhere on the board
IO35_HOME3: R34.1, R35.2; also elsewhere on the board
IO36_HOME1: R27.1, R28.2; also elsewhere on the board
IO39_HOME5: R44.1, R45.2; also elsewhere on the board
MACRO1: J16.1, R62.1, R104.1, SW9.1
MACRO2: J16.3, R63.1, R105.1, SW10.1
MACRO3: J16.5, R80.1, R106.1, SW11.1
unnamed: C48.1, R25.2, R26.1, U25.14
unnamed: C49.1, R25.1, U22.1
unnamed: C50.1, R31.1, U22.3
unnamed: C51.1, R31.2, R32.1, U25.16
unnamed: C52.1, R36.1, U22.5
unnamed: C53.1, R36.2, R37.1, U24.10
unnamed: C54.1, R41.1, U22.9
unnamed: C55.1, R41.2, R42.1, U24.12
unnamed: C56.1, R52.1, U22.11
unnamed: C57.1, R53.1, U22.13
unnamed: C58.1, R54.1, U23.1
unnamed: C59.1, R55.1, U23.3
unnamed: C60.1, R52.2, R56.1, U24.14
unnamed: C61.1, R53.2, R57.1, U24.16
unnamed: C62.1, R54.2, R58.1, U25.12
unnamed: C63.1, R55.2, R59.1, U25.10
unnamed: C64.1, R72.1, U23.5
unnamed: C65.1, R73.1, U23.9
unnamed: C66.1, R74.1, U23.11
unnamed: C68.1, R72.2, R76.1, U21.16
unnamed: C69.1, R73.2, R77.1, U21.14
unnamed: C70.1, R74.2, R78.1, U21.12
unnamed: D29.2 (A), R98.2
unnamed: D30.2 (A), R99.2
unnamed: D31.2 (A), R100.2
unnamed: D32.2 (A), R101.2
unnamed: D33.2 (A), R102.2
unnamed: D34.2 (A), R103.2
unnamed: D35.2 (A), R104.2
unnamed: D36.2 (A), R105.2
unnamed: D37.2 (A), R106.2
unnamed: D38.2 (A), R107.2
unnamed: D39.2 (A), R108.2
unnamed: R24.2, U25.3
unnamed: R33.2, U25.1
unnamed: R38.2, U24.7
unnamed: R43.2, U24.5
unnamed: R60.2, U24.3
unnamed: R61.2, U24.1
unnamed: R62.2, U25.5
unnamed: R63.2, U25.7
unnamed: R80.2, U21.1
unnamed: R81.2, U21.3
unnamed: R82.2, U21.5
PAUSE: J16.7, R81.1, R107.1, SW13.1
RESUME: J16.9, R82.1, R108.1, SW12.1
~HOME1: R27.2, U22.2
~HOME2: R29.2, U22.4
~HOME3: R34.2, U22.6
~HOME4: R39.2, U22.8
~HOME5: R44.2, U22.10
~HOME6: R46.2, U22.12
~MACRO1: R48.2, U23.2
~MACRO2: R50.2, U23.4
~MACRO3: R64.2, U23.6
~PAUSE: R66.2, U23.8
~RESUME: R68.2, U23.10
