# Repository Niko98407/FluidNC_Controller (continued)

## KiCad design kicad/FluidNC/FluidNC.kicad_pcb (continued)

Parts:
A1, A2, A3, A4, A5, A6: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
C25, C26, C27, C28, C29, C30, C32, C33, C34, C35, C36, C37: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C43, C44, C45, C46, C47: 330u / 35V; CP_Elec_8x10.5
J4, J5, J6, J7, J8, J9: Conn_01x05_Socket; WAGO_250-205_1x05_P3.50mm
SW3, SW4, SW5, SW6, SW7, SW8: SW_DIP_x03; DIP-6_W7.62mm_Socket_LongPads
U13, U15, U16, U17, U18, U19: ADuM120N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C25.1, C27.1, C29.1, C32.1, C33.1, C34.1, U13.1 (VDD1), U15.1 (VDD1), U16.1 (VDD1), U17.1 (VDD1), U18.1 (VDD1), U19.1 (VDD1); also elsewhere on the board
+5VP: A1.2 (~FLT), A2.2 (~FLT), A3.2 (~FLT), A4.2 (~FLT), A5.2 (~FLT), A6.2 (~FLT), C26.1, C28.1, C30.1, C35.1, C36.1, C37.1, SW3.1, SW3.2, SW3.3, SW4.1, SW4.2, SW4.3, SW5.1, SW5.2, SW5.3, SW6.1, SW6.2, SW6.3, SW7.1, SW7.2, SW7.3, SW8.1, SW8.2, SW8.3, U13.8 (VDD2), U15.8 (VDD2), U16.8 (VDD2), U17.8 (VDD2), U18.8 (VDD2), U19.8 (VDD2); also elsewhere on the board
+24V: A1.8 (VMOT), A2.8 (VMOT), A3.8 (VMOT), A4.8 (VMOT), A5.8 (VMOT), A6.8 (VMOT), C42.1, C43.1, C44.1, C45.1, C46.1, C47.1; also elsewhere on the board
DIR1: A1.16 (DIR), U13.6 (VOB)
DIR2: A2.16 (DIR), U15.6 (VOB)
DIR3: A3.16 (DIR), U16.6 (VOB)
DIR4: A4.16 (DIR), U17.6 (VOB)
DIR5: A5.16 (DIR), U18.6 (VOB)
DIR6: A6.16 (DIR), U19.6 (VOB)
EN_STEPPER: A1.9 (~EN), A2.9 (~EN), A3.9 (~EN), A4.9 (~EN), A5.9 (~EN), A6.9 (~EN); also elsewhere on the board
GND: C25.2, C27.2, C29.2, C32.2, C33.2, C34.2, U13.4 (GND1), U15.4 (GND1), U16.4 (GND1), U17.4 (GND1), U18.4 (GND1), U19.4 (GND1); also elsewhere on the board
GND1: A1.1 (GND), A1.7 (GND), A2.1 (GND), A2.7 (GND), A3.1 (GND), A3.7 (GND), A4.1 (GND), A4.7 (GND), A5.1 (GND), A5.7 (GND), A6.1 (GND), A6.7 (GND), C26.2, C28.2, C30.2, C35.2, C36.2, C37.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, J4.5, J5.5, J6.5, J7.5, J8.5, J9.5, U13.5 (GND2), U15.5 (GND2), U16.5 (GND2), U17.5 (GND2), U18.5 (GND2), U19.5 (GND2); also elsewhere on the board
I2SO0_DIR6: U19.3 (VIB); also elsewhere on the board
I2SO1_STEP6: U19.2 (VIA); also elsewhere on the board
I2SO2_DIR5: U18.3 (VIB); also elsewhere on the board
I2SO3_STEP5: U18.2 (VIA); also elsewhere on the board
I2SO4_DIR4: U17.3 (VIB); also elsewhere on the board
I2SO5_STEP4: U17.2 (VIA); also elsewhere on the board
I2SO6_DIR3: U16.3 (VIB); also elsewhere on the board
I2SO7_STEP3: U16.2 (VIA); also elsewhere on the board
I2SO8_DIR2: U15.3 (VIB); also elsewhere on the board
I2SO9_STEP2: U15.2 (VIA); also elsewhere on the board
I2SO10_DIR1: U13.3 (VIB); also elsewhere on the board
I2SO11_STEP1: U13.2 (VIA); also elsewhere on the board
unnamed: A1.4 (A1), J4.2
unnamed: A1.3 (A2), J4.1
unnamed: A1.5 (B1), J4.3
unnamed: A1.6 (B2), J4.4
unnamed: A1.10 (M0), SW3.6
unnamed: A1.11 (M1), SW3.5
unnamed: A1.12 (M2), SW3.4
unnamed: A1.13 (~RST), A1.14 (~SLP)
unnamed: A2.4 (A1), J5.2
unnamed: A2.3 (A2), J5.1
unnamed: A2.5 (B1), J5.3
unnamed: A2.6 (B2), J5.4
unnamed: A2.10 (M0), SW4.6
unnamed: A2.11 (M1), SW4.5
unnamed: A2.12 (M2), SW4.4
unnamed: A2.13 (~RST), A2.14 (~SLP)
unnamed: A3.4 (A1), J6.2
unnamed: A3.3 (A2), J6.1
unnamed: A3.5 (B1), J6.3
unnamed: A3.6 (B2), J6.4
unnamed: A3.10 (M0), SW5.6
unnamed: A3.11 (M1), SW5.5
unnamed: A3.12 (M2), SW5.4
unnamed: A3.13 (~RST), A3.14 (~SLP)
unnamed: A4.4 (A1), J7.2
unnamed: A4.3 (A2), J7.1
unnamed: A4.5 (B1), J7.3
unnamed: A4.6 (B2), J7.4
unnamed: A4.10 (M0), SW6.6
unnamed: A4.11 (M1), SW6.5
unnamed: A4.12 (M2), SW6.4
unnamed: A4.13 (~RST), A4.14 (~SLP)
unnamed: A5.4 (A1), J8.2
unnamed: A5.3 (A2), J8.1
unnamed: A5.5 (B1), J8.3
unnamed: A5.6 (B2), J8.4
unnamed: A5.10 (M0), SW7.6
unnamed: A5.11 (M1), SW7.5
unnamed: A5.12 (M2), SW7.4
unnamed: A5.13 (~RST), A5.14 (~SLP)
unnamed: A6.4 (A1), J9.2
unnamed: A6.3 (A2), J9.1
unnamed: A6.5 (B1), J9.3
unnamed: A6.6 (B2), J9.4
unnamed: A6.10 (M0), SW8.6
unnamed: A6.11 (M1), SW8.5
unnamed: A6.12 (M2), SW8.4
unnamed: A6.13 (~RST), A6.14 (~SLP)
STEP1: A1.15 (STEP), U13.7 (VOA)
STEP2: A2.15 (STEP), U15.7 (VOA)
STEP3: A3.15 (STEP), U16.7 (VOA)
STEP4: A4.15 (STEP), U17.7 (VOA)
STEP5: A5.15 (STEP), U18.7 (VOA)
STEP6: A6.15 (STEP), U19.7 (VOA)

Board: 2 copper layers, 210.0 x 120.0 mm, 342 parts (0 on the bottom side), 269 nets.

Other parts of the board:
M3, M3#2, M3#3, M3#4, M3#5, M3#6: MountingHole_3.2mm_M3_Pad_Via

## Commit log

2024-02-17 add Project
2024-02-23 USB-C CC fix
2024-02-23 Add V1
2024-04-14 remove uln2003
2024-04-28 Update schematic
    reduce size, changed connectors, improoved schematic
2024-04-29 partly route pcb
2024-04-30 update KiCad8
2024-05-01 Finish V2 R1
2024-05-01 Add V2R1
2024-05-03 Add debug features
    Change PCB Color
    Add ground pins for probing
    Add debug leds for step, dir and stepper_en
    Add silkscreen with pin definitions
2024-05-05 updat values
2024-05-05 add bom
2024-05-08 Revert "add step, png and bom"
    This reverts commit d8eb2b1d4917e883cea8a4f7078f9344f1f98b85.
2024-05-22 Update schematic
    Remove 1N4148 in PWM to 10V converter, connect test input buttons to 24V instead of ground, tune some resistors and caps
2024-05-23 Minor changes
    Add designated 3.2mm hole footprints,
    update packages
